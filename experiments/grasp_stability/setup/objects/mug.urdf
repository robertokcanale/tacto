Commit message: OpticalFlowTests

File: experiments/grasp_stability/setup/objects/mug.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=mug.obj scale=0.9 0.9 0.9; visual mesh filename=mug.obj
